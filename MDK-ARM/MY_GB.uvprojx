# Keil uVision project MY_GB.uvprojx, settings and files
target MY_GB (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: MY_GB +hex
  AfterMake: D:\software\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o .\MY_GB\GBupdate.bin .\MY_GB\MY_GB.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx,HAS_AWTK_CONFIG
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Modules;../Middlewares/Third_Party/FatFs/src;..\Modules\NES;..\Modules\memery;..\modules\awtk\src;..\modules\awtk\src\ext_widgets;..\modules\awtk-port;..\modules\awtk\3rd;D:\AWTK\SDK\user_apps\001 myDemo\src;D:\AWTK\SDK\user_apps\001 myDemo\res
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x1e000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/User
    ../Src/: flash_if.c main.c gpio.c adc.c dac.c dma.c bsp_driver_sd.c sd_diskio.c fatfs.c fatfs_platform.c sdio.c spi.c usart.c usb_device.c usbd_conf.c usbd_desc.c usbd_storage_if.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Modules
    ../Modules/: oled.c
    ../Modules/memery/: malloc.c
  group Modules/NES
    ../Modules/NES/: nes_apu.c nes_main.c nes_mapper.c nes_ppu.c
    ../modules/NES/: cart.s 6502.s
  group AWTK
    ../modules/awtk/src/: awtk_global.c
    ../modules/awtk/src/tkc/: asset_info.c buffer.c color.c color_parser.c compressor.c crc.c darray.c data_reader.c data_reader_factory.c data_reader_file.c data_writer.c data_writer_factory.c data_writer_file.c date_time.c easing.c emitter.c event.c event_source.c event_source_fd.c event_source_idle.c event_source_manager.c event_source_manager_default.c event_source_timer.c expr_eval.c fs.c func_call_parser.c idle_info.c idle_manager.c int_str.c iostream.c istream.c log.c matrix.c mem.c named_value.c object.c object_array.c object_default.c ostream.c path.c qaction.c rect.c ring_buffer.c rom_fs.c slist.c socket_helper.c socket_pair.c str.c str_str.c time_now.c timer_info.c timer_manager.c tokenizer.c utf8.c utils.c value.c value_desc.c wstr.c
    ../modules/awtk/src/base/: asset_loader.c asset_loader_default.c asset_loader_zip.c assets_manager.c bitmap.c canvas.c children_layouter.c children_layouter_factory.c clip_board.c date_time_format.c dialog.c dialog_highlighter.c dialog_highlighter_factory.c enums.c event_queue.c events.c font.c font_loader.c font_manager.c glyph_cache.c graphic_buffer.c hscrollable.c idle.c image_base.c image_loader.c image_manager.c input_device_status.c input_engine.c input_method.c layout.c lcd.c lcd_profile.c locale_info.c main_loop.c native_window.c self_layouter.c self_layouter_factory.c shortcut.c style.c style_const.c style_factory.c style_mutable.c suggest_words.c system_info.c text_edit.c theme.c timer.c ui_builder.c ui_feedback.c ui_loader.c velocity.c vgcanvas.c widget.c widget_animator.c widget_animator_factory_null.c widget_animator_manager.c widget_factory.c widget_vtable.c window.c window_animator.c window_animator_factory.c window_base.c window_manager.c
    ../modules/awtk/src/widgets/: app_bar.c button.c button_group.c calibration_win.c check_button.c clip_view.c color_tile.c column.c combo_box.c combo_box_item.c dialog_client.c dialog_helper.c dialog_title.c digit_clock.c dragger.c edit.c grid.c grid_item.c group_box.c image.c label.c overlay.c pages.c popup.c progress_bar.c row.c slider.c spin_box.c system_bar.c tab_button.c tab_button_group.c tab_control.c view.c widgets.c
    ../modules/awtk/src/xml/: xml_builder.c xml_parser.c
    ../modules/awtk/src/ui_loader/: ui_binary_writer.c ui_builder_default.c ui_loader_default.c ui_loader_xml.c ui_serializer.c ui_xml_writer.c window_open.c
    ../modules/awtk/src/font_loader/: font_loader_bitmap.c font_loader_ft.c font_loader_stb.c
    ../modules/awtk/src/image_loader/: image_loader_stb.c
    ../modules/awtk/src/input_engines/: input_engine_null.c
    ../modules/awtk/src/input_methods/: input_method_creator.c
    ../modules/awtk/src/main_loop/: main_loop_simple.c
    ../modules/awtk/src/native_window/: native_window_raw.c
    ../modules/awtk/src/window_manager/: window_manager_default.c
    ../modules/awtk/src/graphic_buffer/: graphic_buffer_default.c
    ../modules/awtk/src/platforms/raw/: fs_os.c mutex_null.c sys_tick_handler.c
    ../modules/awtk/src/vgcanvas/: vgcanvas_null.c
    ../Modules/awtk/src/layouters/: children_layouter_builtins.c children_layouter_default.c children_layouter_parser.c self_layouter_builtins.c self_layouter_default.c self_layouter_menu.c self_layouter_parser.c
    ../Modules/awtk/src/clip_board/: clip_board_default.c
    ../Modules/awtk/src/base/: line_break.c
    ../Modules/awtk/3rd/libunibreak/: linebreakdata.c linebreakdef.c linebreak.c emojidef.c graphemebreak.c unibreakbase.c unibreakdef.c wordbreak.c
    ../Modules/awtk/src/blend/: image_g2d.c blend_image_bgr565_bgr565.c blend_image_bgr565_bgra8888.c blend_image_bgr565_rgba8888.c blend_image_bgr888_bgr565.c blend_image_bgr888_bgra8888.c blend_image_bgr888_rgba8888.c blend_image_bgra8888_bgr565.c blend_image_bgra8888_bgra8888.c blend_image_bgra8888_rgba8888.c blend_image_rgb565_bgr565.c blend_image_rgb565_bgra8888.c blend_image_rgb565_rgba8888.c blend_image_rgb888_bgr565.c blend_image_rgb888_bgra8888.c blend_image_rgb888_rgba8888.c blend_image_rgba8888_bgr565.c blend_image_rgba8888_bgra8888.c blend_image_rgba8888_rgba8888.c fill_image_abgr8888.c fill_image_argb8888.c fill_image_bgr565.c fill_image_bgr888.c fill_image_bgra8888.c fill_image_rgb565.c fill_image_rgb888.c fill_image_rgba8888.c rotate_image_bgr565.c rotate_image_bgr888.c rotate_image_bgra8888.c rotate_image_rgb565.c rotate_image_rgb888.c rotate_image_rgba8888.c soft_g2d.c stm32_g2d.c
    ../Modules/awtk/src/ext_widgets/: ext_widgets.c
    ../Modules/awtk/src/ext_widgets/canvas_widget/: canvas_widget.c
    ../Modules/awtk/src/ext_widgets/color_picker/: color_component.c color_picker.c rgb_and_hsv.c
    ../Modules/awtk/src/ext_widgets/combo_box_ex/: combo_box_ex.c
    ../Modules/awtk/src/ext_widgets/features/: draggable.c
    ../Modules/awtk/src/ext_widgets/file_browser/: file_browser.c file_browser_view.c file_chooser.c
    ../Modules/awtk/src/ext_widgets/gif_image/: gif_image.c
    ../Modules/awtk/src/ext_widgets/guage/: guage.c guage_pointer.c
    ../Modules/awtk/src/ext_widgets/image_animation/: image_animation.c
    ../Modules/awtk/src/ext_widgets/image_value/: image_value.c
    ../Modules/awtk/src/ext_widgets/keyboard/: candidates.c keyboard.c
    ../Modules/awtk/src/ext_widgets/mledit/: line_number.c mledit.c
    ../Modules/awtk/src/ext_widgets/mutable_image/: mutable_image.c
    ../Modules/awtk/src/ext_widgets/progress_circle/: progress_circle.c
    ../Modules/awtk/src/ext_widgets/rich_text/: rich_text.c rich_text_node.c rich_text_parser.c rich_text_render_node.c
    ../Modules/awtk/src/ext_widgets/scroll_label/: hscroll_label.c
    ../Modules/awtk/src/ext_widgets/scroll_view/: children_layouter_list_view.c list_item.c list_view.c list_view_h.c scroll_bar.c scroll_view.c
    ../Modules/awtk/src/ext_widgets/slide_menu/: slide_menu.c
    ../Modules/awtk/src/ext_widgets/slide_view/: slide_indicator.c slide_view.c
    ../Modules/awtk/src/ext_widgets/svg_image/: svg_image.c
    ../Modules/awtk/src/ext_widgets/switch/: switch.c
    ../Modules/awtk/src/ext_widgets/text_selector/: text_selector.c
    ../Modules/awtk/src/ext_widgets/time_clock/: time_clock.c
    ../Modules/awtk/src/svg/: bsvg.c bsvg_builder.c bsvg_draw.c bsvg_to_svg.c svg_path.c svg_path_parser.c svg_shape.c svg_to_bsvg.c
    ../Modules/awtk/src/window_animators/: window_animator_builtins.c window_animator_center_scale.c window_animator_common.c window_animator_fade.c window_animator_htranslate.c window_animator_popdown.c window_animator_popup.c window_animator_slide.c window_animator_slide_down.c window_animator_slide_left.c window_animator_slide_right.c window_animator_slide_up.c window_animator_vtranslate.c
    ../Modules/awtk/src/widget_animators/: widget_animator_factory.c widget_animator_prop.c widget_animator_prop2.c widget_animator_scroll.c
  group AWTK/Port
    ../modules/awtk-port/: assert.c gui_main.c lcd_stm32_raw.c main_loop_stm32_raw.c platform.c SysTick.c
    D:/AWTK/SDK/user_apps/001 myDemo/src/: app_main.c window_main.c
software components: RTOS:Config 9.0.0, RTOS:Core 9.0.0, RTOS:Heap 9.0.0, RTOS:Timers 9.0.0, CMSIS:CORE 5.1.2, Device:Startup 2.6.0
